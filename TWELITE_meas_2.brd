# Repository ta-inoue-SPT/TWELITEmeas2-1

## EAGLE design TWELITE_meas_2.brd

Parts:
J1: 535541-6; TE_535541-6
J3: 535541-3; TE_535541-3
U1: LITE_1

Connections:
A|1: J3.4, U1.P$23 (AI1)
A|3: J3.5, U1.P$22 (AI3)
E-HARVEST_GND: J3.2, U1.P$6 (DO3)
GND: J1.1, J3.3, U1.P$20 (GND), U1.P$28 (GND2)
GND_SW: J1.8, U1.P$26 (M2)
PRG: J1.3, U1.P$2 (PWM3)
RST: J1.5, U1.P$21 (RST)
RXD: J1.4, U1.P$9 (UT-RX)
TXD: J1.2, U1.P$8 (UT-TX)
VCC: J1.6, J3.1, U1.P$5 (VCC)

Notes on the sheet:
レクテナ取付（計測用）
TWELITE
GND
TXD
PRG
RXD
RST
VCC33
GND(SW)
Qi (P2.54)
A|1
A|3
VCC
E-HARVEST(GND)
test

Board: 2 copper layers, 28.0 x 22.0 mm, 3 parts (0 on the bottom side), 10 nets.

## Commit log

2021-06-07 start
